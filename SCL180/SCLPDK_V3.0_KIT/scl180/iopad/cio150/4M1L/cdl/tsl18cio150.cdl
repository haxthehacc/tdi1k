*  Tower Semiconductor 28 June 2007
*  -------------------------------------- *
*  @(#) tsl18cio150 CDL File
*  @(#) Revision 1.1
*  @(#) Date 28-Jun-2007
*  ------------------------------------------------------------- *
*  Copyright (c) 2003 Synopsys, Inc.  All Rights Reserved
*  This information is provided pursuant to a license agreement
*  that grants limited rights of access/use and requires that
*  the information be treated as confidential.
*  ------------------------------------------------------------- *
*  Written by: makecdl.pl, rev. main/1
*  Filename: tsl18cio150.cdl
*  Total subcircuits:  93
*  -------------------------------------- *
*  Defining the default unit for both length and area
*.SCALE meter
*  -------------------------------------- *
*  Note:
*  ====
*  If you use the power pad set:
*
*         pv0f
*
*  you must replace *.EQUIV XXX=YYY by the following:
*
*       *.EQUIV  VSS=VSSO
*
*.EQUIV XXX=YYY
.SUBCKT apc3d01 CIN PAD VSS AVSS AVDD AVDDO AVSSO
M1      U9_MPI2_drain U14_padr AVDDO   AVDDO   PH   L=.3600U
+  W=20.0000U
M2      U9_MPI1_drain U14_padr U9_MPI2_drain AVDDO   PH   L=.3600U
+  W=20.0000U
M3      U14_padr net_m3_AVDDO_res   AVDDO   AVDDO   PH   L=.3600U  W=20.0000U
M4      CIN     U9_MPI1_drain AVDD    AVDD    PH   L=.3600U
+  W=32.0000U
M5      U9_MPI1_drain U14_padr AVSSO   AVSSO   NH   L=.3600U
+  W=6.0000U
M6      U14_padr net_m6_AVSSO_res   AVSSO   AVSSO   NH   L=.3600U  W=20.0000U
M7      CIN     U9_MPI1_drain AVSS    AVSS    NH   L=.3600U
+  W=6.0000U
M9      U14_pgate_tol net_m9_AVDDO_res   U14_pgate_tol AVSSO   NH   L=.3600U
+  W=50.0000U
M10     U14_pgate_tol net_m10_AVSSO_res   U14_pgate_tol AVDDO   PH   L=.3600U
+  W=50.0000U
M13     AVDDO   net_m13_AVDDO_res   U14_pgate_tol AVSSO   NH   L=.3600U
+  W=10.0000U
M14     U14_pgate_tol net_m14_AVSSO_res   AVDDO   AVDDO   PH   L=.3600U
+  W=20.0000U
M15     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M16     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M17     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M18     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M19     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M20     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M21     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M22     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M23     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M24     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M25     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M26     PAD     U14_U71_r1 AVSSO   AVSSO   NH   L=.5000U  W=30.0000U
M27     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M28     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M29     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M30     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M31     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M32     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M33     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M34     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M35     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M36     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M37     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
M38     AVDDO   U14_pgate_tol PAD     AVDDO   PH   L=.4000U
+  W=52.0000U
D39     AVSSO   VSS     P3  93.1700P 200.3400U
D40     VSS     AVSSO   P3  93.1700P 200.3400U
R8      U14_U71_r1 AVSSO   4.8910K $[RW] W=2.1U L=8.65U
R11     U14_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R12     U14_padr U14_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U

RM3   net_m3_AVDDO_res   AVDDO   1180.0000 $[RD]
RM6   net_m6_AVSSO_res   AVSSO   1180.0000 $[RD]
RM9   net_m9_AVDDO_res   AVDDO   1180.0000 $[RD]
RM10   net_m10_AVSSO_res   AVSSO   1180.0000 $[RD]
RM13   net_m13_AVDDO_res   AVDDO   1180.0000 $[RD]
RM14   net_m14_AVSSO_res   AVSSO   1180.0000 $[RD]

.ENDS apc3d01
.SUBCKT apv0a AVSSO VSS AVSS AVDD AVDDO
C6_7    AVDDO   U31_U29_c2 L= 15.13U W=15.13U $[CH]
M4      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M5      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M6      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M7      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M8      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M9      AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M10     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M11     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M12     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M13     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M14     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M15     AVDDO   U31_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M18     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M19     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M20     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M21     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M22     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M23     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M24     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M25     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M26     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M27     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M28     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M29     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
D30     AVSSO   VSS     P3  119.7900P 257.5800U
D31     VSS     AVSSO   P3  119.7900P 257.5800U
R2      U31_U29_c2 U31_U18_r2 8.2500K $[RW] W=2.1U L=14.6U
R3      U31_U18_r2 AVSSO   8.2500K $[RW] W=2.1U L=14.6U
R16     U19_U31_r1 U19_U31_r2 8.2500K $[RW] W=2.1U L=14.6U
R17     AVDDO   U19_U31_r1 8.2500K $[RW] W=2.1U L=14.6U

.ENDS apv0a
.SUBCKT apv0i AVSS VSS AVDD AVDDO AVSSO
C4_10   AVDD    U38_U18_r1 L= 15.13U W=15.13U $[CH]
M3      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M4      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M5      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M6      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M7      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M8      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M9      AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M10     AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M11     AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M12     AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M13     AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M14     AVSS    U39_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M18     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M19     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M20     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M21     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M22     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M23     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M24     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M25     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M26     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M27     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M28     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
M29     AVDD    U38_U18_r1 AVSS    AVSS    N  L=.2500U  W=30.0000U
D30     VSS     AVSS    P3  119.7900P 257.5800U
D31     AVSS    VSS     P3  119.7900P 257.5800U
R1      U39_U31_r1 U39_U31_r2   8.2500K $[RW] W=2.1U L=14.6U
R2      AVDD    U39_U31_r1   8.2500K $[RW] W=2.1U L=14.6U
R15     U38_U31_r1 AVSS      8.2500K $[RW] W=2.1U L=14.6U
R16     U38_U18_r1 U38_U31_r1   8.2500K $[RW] W=2.1U L=14.6U

.ENDS apv0i
.SUBCKT apvda AVDDO VSS AVSS AVDD AVSSO
C3_7    AVDDO   U30_U29_c2 L= 15.13U W=15.13U $[CH]
M4      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M5      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M6      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M7      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M8      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M9      AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M10     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M11     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M12     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M13     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M14     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M15     AVDDO   U30_U29_c2 AVSSO   AVSSO   NH   L=.4000U  W=30.0000U
M18     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M19     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M20     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M21     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M22     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M23     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M24     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M25     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M26     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M27     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M28     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
M29     AVSSO   U19_U31_r2 AVDDO   AVDDO   PH   L=.4000U  W=40.0000U
D30     AVSSO   VSS     P3  119.7900P 257.5800U
D31     VSS     AVSSO   P3  119.7900P 257.5800U
R2      U30_U29_c2 U30_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R3      U30_U18_r2 AVSSO   8.2500K $[RW]  W=2.1U L=14.6U
R16     U19_U31_r1 U19_U31_r2 8.2500K $[RW]  W=2.1U L=14.6U
R17     AVDDO   U19_U31_r1 8.2500K $[RW]  W=2.1U L=14.6U

.ENDS apvda
.SUBCKT apvdi AVDD VSS AVSS AVDDO AVSSO
C3_10   AVDD    U33_U18_r1 L= 15.13U W=15.13U $[CH]
M3      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M4      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M5      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M6      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M7      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M8      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M9      AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M10     AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M11     AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M12     AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M13     AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M14     AVSS    U34_U31_r2 AVDD    AVDD    P  L=.2500U  W=40.0000U
M18     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M19     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M20     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M21     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M22     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M23     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M24     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M25     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M26     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M27     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M28     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
M29     AVDD    U33_U18_r1 AVSSO   AVSSO   N  L=.2500U  W=30.0000U
D30     VSS     AVSS    P3  119.7900P 257.5800U
D31     AVSS    VSS     P3  119.7900P 257.5800U
R1      U34_U31_r1 U34_U31_r2   8.2500K $[RW]  W=2.1U L=14.6U
R2      AVDD    U34_U31_r1   8.2500K $[RW] W=2.1U L=14.6U
R15     U33_U31_r1 AVSS      8.2500K $[RW] W=2.1U L=14.6U
R16     U33_U18_r1 U33_U31_r1   8.2500K $[RW] W=2.1U L=14.6U

.ENDS apvdi
.SUBCKT pc3b01 PAD I OEN CIN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M57     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M58     U27_padr net_m58_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M59     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M60     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M61     U27_padr net_m61_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M62     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW] W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM58   net_m58_VDDO_res   VDDO   1180.0000 $[RD]
RM61   net_m61_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b01
.SUBCKT pc3b01d PAD I OEN CIN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U27_padr net_m56_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M57     U28_U22_source net_m57_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M58     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M59     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M60     U27_padr net_m60_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M61     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M62     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M63     U27_padr net_m63_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M64     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW] W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM56   net_m56_VDDO_res   VDDO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM60   net_m60_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b01d
.SUBCKT pc3b01u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U27_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M4      U27_padr net_m4_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M5      CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M6      U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M7      U27_padr net_m7_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M8      CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M9      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M10     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M11     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M12     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M13     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M14     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M15     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M16     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M17     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M18     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M19     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M21     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M22     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M23     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M24     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M25     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M26     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M27     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M29     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M30     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M31     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M33     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M34     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M35     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M36     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M37     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M38     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M39     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M40     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M41     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M42     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M43     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M44     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M45     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M56     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M57     U15_pgate net_m57_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M58     U15_pgate net_m58_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M62     VDDO    net_m62_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M63     U27_U71_UN_P_TOP net_m63_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
D20     VSS     I       DN  250.0000F 2.0000U
D28     VSS     OEN     DN  250.0000F 2.0000U
R59     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R60     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R61     U27_U69$9_gate VSSO    4.8910K $[RW] W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM7   net_m7_VSSO_res   VSSO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM58   net_m58_VSSO_res   VSSO   1180.0000 $[RD]
RM62   net_m62_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b01u
.SUBCKT pc3b02 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M66     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M67     U27_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b02
.SUBCKT pc3b02d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M66     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M67     U27_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M69     U27_padr net_m69_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U28_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b02d
.SUBCKT pc3b02u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M66     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M67     U27_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M69     U27_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b02u
.SUBCKT pc3b03 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b03
.SUBCKT pc3b03d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VDDO_res    U29_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M72     U29_U22_source net_m72_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]
RM72   net_m72_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b03d
.SUBCKT pc3b03ed PAD I OEN CIN RENB VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U30_MN3_drain U30_U24_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M72     U30_MN3_drain U30_U24_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=6.0000U
M73     U30_U24_nsgate RENB    VSS     VSS     N   L=.3600U
+  W=6.0000U
M74     U30_U24_U6_drain U30_U24_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=6.0000U
M75     U30_U24_OUTSHIFT U30_U24_U6_drain VDDO    VDDO    PH
+  L=.3600U  W=6.0000U
M76     U30_U24_U6_drain RENB    VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M77     U30_U24_OUTSHIFT U30_U24_nsgate VSSO    VSS     NH   L=.3600U
+   W=10.0000U
M78     U30_U24_nsgate RENB    VDD     VDD     P   L=.2000U
+  W=2.7800U
M80     U28_padr U30_MN3_drain U30_U22_source VSS     NH   L=5.5000U
+  W=1.3300U
M81     U30_U22_source U30_MN3_drain VSSO    VSS     NH   L=5.5000U
+  W=1.3300U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
D79     VSS     RENB    DN  1.0000P 4.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b03ed
.SUBCKT pc3b03u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b03u
.SUBCKT pc3b04 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b04
.SUBCKT pc3b04d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VDDO_res    U30_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M72     U30_U22_source net_m72_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]
RM72   net_m72_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b04d
.SUBCKT pc3b04u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b04u
.SUBCKT pc3b05 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b05
.SUBCKT pc3b05d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M8      U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M9      U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M10     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M11     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M13     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M15     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M16     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M17     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M19     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M20     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M21     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M22     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M23     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M24     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M25     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M27     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M28     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M29     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M30     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M31     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M32     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M33     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M34     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M35     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M36     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M37     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M38     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M39     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M40     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M41     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M42     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M43     U30_pgate net_m43_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M44     U30_pgate net_m44_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M47     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M48     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M49     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M56     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M57     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M58     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M59     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M60     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M62     VDDO    net_m62_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M63     U29_U71_UN_P_TOP net_m63_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U29_padr net_m71_VDDO_res    U31_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M72     U31_U22_source net_m72_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D18     VSS     I       DN  250.0000F 2.0000U
D26     VSS     OEN     DN  250.0000F 2.0000U
R45     U29_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R46     U29_padr U29_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R61     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM43   net_m43_VDDO_res   VDDO   1180.0000 $[RD]
RM44   net_m44_VSSO_res   VSSO   1180.0000 $[RD]
RM62   net_m62_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]
RM72   net_m72_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b05d
.SUBCKT pc3b05u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U29_padr net_m71_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3b05u
.SUBCKT pc3b21eu PAD I OEN RENB CIN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U26_U34_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M57     U26_U36_drain U27_padr U26_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M58     U27_padr net_m58_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M59     VDDO    U26_U36_drain U26_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M60     CIN     U26_U36_drain VSS     VSS     NH   L=.3600U
+  W=4.0000U
M61     U26_U36_drain U27_padr U26_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M62     U26_U30_source U27_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M63     U27_padr net_m63_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M64     VSSO    U26_U36_drain U26_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M65     CIN     U26_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M66     U32_U1_nsgate RENB    VSS     VSS     N   L=.3600U  W=6.0000U
+
M67     U32_U1_U6_drain U32_U1_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M68     U32_U1_OUTSHIFT U32_U1_U6_drain VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M69     U32_U1_U6_drain RENB    VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M70     U32_U1_OUTSHIFT U32_U1_nsgate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M71     U32_U1_nsgate RENB    VDD     VDD     P   L=.2000U  W=2.7800U
+
M73     U27_padr U32_U1_OUTSHIFT VDDO    VDDO    PH   L=2.0000U
+  W=2.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
D72     VSS     RENB    DN  1.0000P 4.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM58   net_m58_VSSO_res   VSSO   1180.0000 $[RD]
RM63   net_m63_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b21eu
.SUBCKT pc3b25eu I OEN CIN RENB PAD VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_U34_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M65     U26_U36_drain U29_padr U26_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M66     U29_padr net_m66_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M67     VDDO    U26_U36_drain U26_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M68     CIN     U26_U36_drain VSS     VSS     NH   L=.3600U
+  W=4.0000U
M69     U26_U36_drain U29_padr U26_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M70     U26_U30_source U29_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M71     U29_padr net_m71_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M72     VSSO    U26_U36_drain U26_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M73     CIN     U26_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M74     U32_U1_nsgate RENB    VSS     VSS     N   L=.3600U  W=6.0000U
+
M75     U32_U1_U6_drain U32_U1_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M76     U32_U1_OUTSHIFT U32_U1_U6_drain VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M77     U32_U1_U6_drain RENB    VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M78     U32_U1_OUTSHIFT U32_U1_nsgate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M79     U32_U1_nsgate RENB    VDD     VDD     P   L=.2000U  W=2.7800U
+
M81     U29_padr U32_U1_OUTSHIFT VDDO    VDDO    PH   L=2.0000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
D80     VSS     RENB    DN  1.0000P 4.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE] W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE] W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3b25eu
.SUBCKT pc3c01 CCLK CP VDD VSS VDDO VSSO
M2      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M3     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M4      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M5     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M6      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M7     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M8      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M9     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M10      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M11      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M12      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M13      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
D1      VSS     CCLK    DN  462.0001F 2.7200U

.ENDS pc3c01
.SUBCKT pc3c02 CCLK CP VDD VSS VDDO VSSO
M1      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M2      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M3      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M4      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M5      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M6      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M7      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M8      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M9      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M10     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M11     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M12    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M13     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M14    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M15     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M16    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M17     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M18    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M19     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M20    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M21     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M22    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M23     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M24    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
D25     VSS     CCLK    DN  462.0001F 2.7200U

.ENDS pc3c02
.SUBCKT pc3c03 CCLK CP VDD VSS VDDO VSSO
M1      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M2      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M3      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M4      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M5      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M6      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M7      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M8      NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M9      NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M10     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M11     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M12     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M13     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M14     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M15     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M16     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M17     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M18    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M19     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M20    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M21     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M22    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M23     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M24    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M25     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M26    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M27     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M28    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M29     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M30    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M31     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M32    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M33     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M34    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M35     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M36    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M37     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M38    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M39     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M40    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M41     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M42    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M43     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M44    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M45     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M46    CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M47     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M48    CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
D49     VSS     CCLK    DN  462.0001F 2.7200U

.ENDS pc3c03
.SUBCKT pc3c04 CCLK CP VDD VSS VDDO VSSO
M1      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M2      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M3      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M4      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M5      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M6      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M7      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M8      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M9      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M10      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M11      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M12      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M13      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M14      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M15      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M16      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M17      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M18      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M19     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M20      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M21     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M22      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M23     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M24      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M25     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M26      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M27     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M28      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M29     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M30      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M31     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M32      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M33     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M34      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M35     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M36      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M37     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M38      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M39     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M40      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M41     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M42      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M43     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M44      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M45     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M46      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M47     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M48      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M49     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M50      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M51     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M52      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M53     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M54      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M55     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M56      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M57     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M58      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M59     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M60      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M61     CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M62      CP      NODE    VSS     VSS     N   L=.1800U  W=13.9000U
M63     CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M64      CP      NODE    VDD     VDD     P   L=.1800U  W=32.3400U
M65     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M66     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M67     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M68     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M69     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M70     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M71     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M72     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M73     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M74     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M75     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M76     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M77     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M78     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M79     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M80     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M81     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M82     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M83     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M84     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M85     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M86     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M87     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M88     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M89     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M90     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M91     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M92     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M93     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M94     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
M95     NODE    CCLK    VDD     VDD     PH   L=.3600U  W=23.5000U
M96     NODE    CCLK    VSS     VSS     NH   L=.3600U  W=10.0000U
D97     VSS     CCLK    DN  462.0001F 2.7200U

.ENDS pc3c04
.SUBCKT pc3d00 PAD PADR VDD VSS VDDO VSSO
M1      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M2      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M3      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M4      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M5      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M6      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M7      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M8      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M9      VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M10     VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M11     VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M12     VDDO    U18_U79$3_gate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     PADR    U18_U82_gate VSS     VSS     NH   L=.4000U  W=30.0000U
+
M19     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M22     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M23     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M24     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M25     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M26     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M27     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M28     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M29     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M30     PAD     U18_U74$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
D31     VSSO    VSS     P3  93.1700P 200.3400U
D32     VSS     VSSO    P3  93.1700P 200.3400U
R13     U18_U13_r1 PADR      302.0000 $[RE] W=4U L=2.5U
R14     PAD     U18_U13_r1   302.0000 $[RE] W=4U L=2.5U
R15     U18_U82_gate VSS       1.1900K $[RW] W=2.1U L=2.1U
R16     U18_U74$11_gate VSSO      4.8910K $[RW]  W=2.1U L=8.65U
R17     VDDO    U18_U79$3_gate   4.8910K $[RW] W=2.1U L=8.65U

.ENDS pc3d00
.SUBCKT pc3d01 CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U9_MPI2_drain U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M33     U9_MPI1_drain U14_padr U9_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M34     U14_padr net_m34_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M35     CIN     U9_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M36     U9_MPI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M37     U14_padr net_m37_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M38     CIN     U9_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM34   net_m34_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d01
.SUBCKT pc3d01d CIN PAD VDD VSS VDDO VSSO
M1      U14_padr net_m1_VDDO_res    U15_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M2      U15_U22_source net_m2_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M3      U9_MPI2_drain U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M4      U9_MPI1_drain U14_padr U9_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M5      U14_padr net_m5_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M6      CIN     U9_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M7      U9_MPI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M8      U14_padr net_m8_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M9      CIN     U9_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M10     VDDO    net_m10_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M11     U14_pgate_tol net_m11_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M12     U14_pgate_tol net_m12_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M13     U14_pgate_tol net_m13_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M22     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M23     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M24     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M25     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M26     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M27     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M37     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M39     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M40     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
R14     U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R15     U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R28     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VDDO_res   VDDO   1180.0000 $[RD]
RM8   net_m8_VSSO_res   VSSO   1180.0000 $[RD]
RM10   net_m10_VDDO_res   VDDO   1180.0000 $[RD]
RM11   net_m11_VSSO_res   VSSO   1180.0000 $[RD]
RM12   net_m12_VDDO_res   VDDO   1180.0000 $[RD]
RM13   net_m13_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d01d
.SUBCKT pc3d01u CIN PAD VDD VSS VDDO VSSO
M1      U14_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      VDDO    net_m2_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M3      U14_pgate_tol net_m3_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M4      U14_pgate_tol net_m4_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M5      U14_pgate_tol net_m5_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     U9_MPI2_drain U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M34     U9_MPI1_drain U14_padr U9_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M35     U14_padr net_m35_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M36     CIN     U9_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M37     U9_MPI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M38     U14_padr net_m38_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M39     CIN     U9_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
R6      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R7      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R20     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM2   net_m2_VDDO_res   VDDO   1180.0000 $[RD]
RM3   net_m3_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VSSO_res   VSSO   1180.0000 $[RD]
RM35   net_m35_VDDO_res   VDDO   1180.0000 $[RD]
RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d01u
.SUBCKT pc3d11 CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U14_padr net_m32_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M33     U9_MNI1_drain U14_padr U9_MPI1_source VDDO    PH   L=.3600U
+  W=20.0000U
M34     U9_MPI1_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M35     U9_U19_gate U9_MNI1_drain VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M36     CIN     U9_U19_gate VDD     VDD     PH   L=.3600U  W=32.0000U
+
M37     U14_padr net_m37_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M38     U9_MNI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M39     CIN     U9_U19_gate VSS     VSS     NH   L=.3600U  W=6.0000U
M40     U9_U19_gate U9_MNI1_drain VSSO    VSS     NH   L=.3600U
+  W=15.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM32   net_m32_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d11
.SUBCKT pc3d11d CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U14_padr net_m32_VDDO_res    U15_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M33     U15_U22_source net_m33_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M34     U14_padr net_m34_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M35     U9_MNI1_drain U14_padr U9_MPI1_source VDDO    PH   L=.3600U
+  W=20.0000U
M36     U9_MPI1_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M37     U9_U19_gate U9_MNI1_drain VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M38     CIN     U9_U19_gate VDD     VDD     PH   L=.3600U  W=32.0000U
+
M39     U14_padr net_m39_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M40     U9_MNI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M41     CIN     U9_U19_gate VSS     VSS     NH   L=.3600U  W=6.0000U
M42     U9_U19_gate U9_MNI1_drain VSSO    VSS     NH   L=.3600U
+  W=15.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM32   net_m32_VDDO_res   VDDO   1180.0000 $[RD]
RM33   net_m33_VDDO_res   VDDO   1180.0000 $[RD]
RM34   net_m34_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d11d
.SUBCKT pc3d11u CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U14_padr net_m32_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M33     U14_padr net_m33_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M34     U9_MNI1_drain U14_padr U9_MPI1_source VDDO    PH   L=.3600U
+  W=20.0000U
M35     U9_MPI1_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M36     U9_U19_gate U9_MNI1_drain VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M37     CIN     U9_U19_gate VDD     VDD     PH   L=.3600U  W=32.0000U
+
M38     U14_padr net_m38_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M39     U9_MNI1_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M40     CIN     U9_U19_gate VSS     VSS     NH   L=.3600U  W=6.0000U
M41     U9_U19_gate U9_MNI1_drain VSSO    VSS     NH   L=.3600U
+  W=15.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM33   net_m33_VDDO_res   VDDO   1180.0000 $[RD]
RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d11u
.SUBCKT pc3d21 CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U9_U34_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M33     U9_U36_drain U14_padr U9_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M34     U14_padr net_m34_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M35     VDDO    U9_U36_drain U9_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M36     CIN     U9_U36_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
M37     U9_U36_drain U14_padr U9_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M38     U9_U30_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M39     U14_padr net_m39_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M40     VSSO    U9_U36_drain U9_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M41     CIN     U9_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM34   net_m34_VSSO_res   VSSO   1180.0000 $[RD]
RM39   net_m39_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3d21
.SUBCKT pc3d21d CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U14_padr net_m32_VDDO_res    U15_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M33     U15_U22_source net_m33_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M34     U9_U34_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M35     U9_U36_drain U14_padr U9_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M36     U14_padr net_m36_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M37     VDDO    U9_U36_drain U9_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M38     CIN     U9_U36_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
M39     U9_U36_drain U14_padr U9_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M40     U9_U30_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M41     U14_padr net_m41_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M42     VSSO    U9_U36_drain U9_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M43     CIN     U9_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM32   net_m32_VDDO_res   VDDO   1180.0000 $[RD]
RM33   net_m33_VDDO_res   VDDO   1180.0000 $[RD]
RM36   net_m36_VSSO_res   VSSO   1180.0000 $[RD]
RM41   net_m41_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3d21d
.SUBCKT pc3d21eu CIN PAD RENB VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U9_U34_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M33     U9_U36_drain U14_padr U9_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M34     U14_padr net_m34_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M35     VDDO    U9_U36_drain U9_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M36     CIN     U9_U36_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
M37     U9_U36_drain U14_padr U9_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M38     U9_U30_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M39     U14_padr net_m39_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M40     VSSO    U9_U36_drain U9_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M41     CIN     U9_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M42     U17_U1_nsgate RENB    VSS     VSS     N   L=.3600U  W=6.0000U
+
M43     U17_U1_U6_drain U17_U1_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M44     U17_U1_OUTSHIFT U17_U1_U6_drain VDDO    VDDO    PH   L=.3600U
+   W=6.0000U
M45     U17_U1_U6_drain RENB    VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M46     U17_U1_OUTSHIFT U17_U1_nsgate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M47     U17_U1_nsgate RENB    VDD     VDD     P   L=.2000U  W=2.7800U
+
M49     U14_padr U17_U1_OUTSHIFT VDDO    VDDO    PH   L=2.0000U
+  W=2.0000U
D48     VSS     RENB    DN  1.0000P 4.0000U
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM34   net_m34_VSSO_res   VSSO   1180.0000 $[RD]
RM39   net_m39_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3d21eu
.SUBCKT pc3d21u CIN PAD VDD VSS VDDO VSSO
M1      U14_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      VDDO    net_m2_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M3      U14_pgate_tol net_m3_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M4      U14_pgate_tol net_m4_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M5      U14_pgate_tol net_m5_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     U9_U34_drain U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M34     U9_U36_drain U14_padr U9_U34_drain VSS     NH   L=.3600U
+  W=6.0000U
M35     U14_padr net_m35_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M36     VDDO    U9_U36_drain U9_U34_drain VSS     NH   L=.3600U
+  W=2.5000U
M37     CIN     U9_U36_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
M38     U9_U36_drain U14_padr U9_U30_source VDDO    PH   L=.3600U
+  W=11.0000U
M39     U9_U30_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M40     U14_padr net_m40_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M41     VSSO    U9_U36_drain U9_U30_source VDDO    PH   L=.3600U
+  W=8.0000U
M42     CIN     U9_U36_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
R6      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R7      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R20     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM2   net_m2_VDDO_res   VDDO   1180.0000 $[RD]
RM3   net_m3_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VSSO_res   VSSO   1180.0000 $[RD]
RM35   net_m35_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3d21u
.SUBCKT pc3d31 CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VSSO    U9_U41_gate U9_U41_source VDDO    PH   L=.3600U
+  W=8.0000U
M33     U9_U41_gate U14_padr U9_U41_source VDDO    PH   L=.3600U
+  W=11.0000U
M34     U9_U41_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M35     U14_padr net_m35_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M36     U9_U43_drain U9_U41_gate VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M37     CIN     U9_U43_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M38     VDDO    U9_U41_gate U9_U33_source VSS     NH   L=.3600U
+  W=2.5000U
M39     U9_U33_source U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M40     U9_U41_gate U14_padr U9_U33_source VSS     NH   L=.3600U
+  W=6.0000U
M41     U14_padr net_m41_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M42     U9_U43_drain U9_U41_gate VSSO    VSS     NH   L=.3600U
+  W=15.0000U
M43     CIN     U9_U43_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM35   net_m35_VDDO_res   VDDO   1180.0000 $[RD]
RM41   net_m41_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d31
.SUBCKT pc3d31d CIN PAD VDD VSS VDDO VSSO
M1      VDDO    net_m1_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M2      U14_pgate_tol net_m2_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U14_pgate_tol net_m3_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M4      U14_pgate_tol net_m4_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M7      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     U14_padr net_m32_VDDO_res    U15_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M33     U15_U22_source net_m33_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M34     VSSO    U9_U41_gate U9_U41_source VDDO    PH   L=.3600U
+  W=8.0000U
M35     U9_U41_gate U14_padr U9_U41_source VDDO    PH   L=.3600U
+  W=11.0000U
M36     U9_U41_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M37     U14_padr net_m37_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M38     U9_U43_drain U9_U41_gate VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M39     CIN     U9_U43_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M40     VDDO    U9_U41_gate U9_U33_source VSS     NH   L=.3600U
+  W=2.5000U
M41     U9_U33_source U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M42     U9_U41_gate U14_padr U9_U33_source VSS     NH   L=.3600U
+  W=6.0000U
M43     U14_padr net_m43_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M44     U9_U43_drain U9_U41_gate VSSO    VSS     NH   L=.3600U
+  W=15.0000U
M45     CIN     U9_U43_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
R5      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R6      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R19     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VDDO_res   VDDO   1180.0000 $[RD]
RM2   net_m2_VSSO_res   VSSO   1180.0000 $[RD]
RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM32   net_m32_VDDO_res   VDDO   1180.0000 $[RD]
RM33   net_m33_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VDDO_res   VDDO   1180.0000 $[RD]
RM43   net_m43_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d31d
.SUBCKT pc3d31u CIN PAD VDD VSS VDDO VSSO
M1      U14_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      VDDO    net_m2_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=10.0000U
M3      U14_pgate_tol net_m3_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M4      U14_pgate_tol net_m4_VDDO_res    U14_pgate_tol VSS     NH   L=.3600U
+  W=50.0000U
M5      U14_pgate_tol net_m5_VSSO_res    U14_pgate_tol VDDO    PH   L=.3600U
+  W=50.0000U
M8      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     PAD     U14_MN4$11_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U14_pgate_tol PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VSSO    U9_U41_gate U9_U41_source VDDO    PH   L=.3600U
+  W=8.0000U
M34     U9_U41_gate U14_padr U9_U41_source VDDO    PH   L=.3600U
+  W=11.0000U
M35     U9_U41_source U14_padr VDDO    VDDO    PH   L=.3600U
+  W=11.0000U
M36     U14_padr net_m36_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M37     U9_U43_drain U9_U41_gate VDDO    VDDO    PH   L=.3600U
+  W=37.5000U
M38     CIN     U9_U43_drain VDD     VDD     PH   L=.3600U
+  W=36.0000U
M39     VDDO    U9_U41_gate U9_U33_source VSS     NH   L=.3600U
+  W=2.5000U
M40     U9_U33_source U14_padr VSSO    VSS     NH   L=.3600U
+  W=9.5000U
M41     U9_U41_gate U14_padr U9_U33_source VSS     NH   L=.3600U
+  W=6.0000U
M42     U14_padr net_m42_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M43     U9_U43_drain U9_U41_gate VSSO    VSS     NH   L=.3600U
+  W=15.0000U
M44     CIN     U9_U43_drain VSS     VSS     NH   L=.3600U  W=4.0000U
+
R6      U14_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R7      U14_padr U14_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R20     U14_MN4$11_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM2   net_m2_VDDO_res   VDDO   1180.0000 $[RD]
RM3   net_m3_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM42   net_m42_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3d31u
.SUBCKT pc3o01 PAD I VDD VSS VDDO VSSO
M3      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M4      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M5      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M16     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M17     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M18     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M19     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M20     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M21     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M22     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M23     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M30     pgate   net_m30_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M31     pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M32     ngate   net_m32_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M33     U28_U16_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M34     U28_ISHF U28_U16_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M35     U28_U16_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M36     U28_ISHF U28_U16_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M37     VDDO    U28_U16_MN1_drai U28_U16_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M38     U28_U16_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M39     U28_U16_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D40     VSS     I       DN  250.0000F 2.0000U
R1      PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R2      U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R27     U29_U74$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R28     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3o01
.SUBCKT pc3o01hv PAD I VDD VSS VDDO VSSO
M1      ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M2      pgate   net_m2_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M3      pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M4      ngate   net_m4_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M5      U28_U13_U6_drain net_m5_VSS_res     VSS     VSS     N   L=.1800U
+  W=5.0000U
M6      U28_U13_U6_drain net_m6_VDD_res     VDD     VDD     P   L=.1800U
+  W=10.0000U
M7      U28_U13_MPLL1_dr I       VDDO    VDDO    PH   L=.3600U
+  W=5.0000U
M8      U28_ISHF U28_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=36.0000U
M9      U28_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=8.0000U
M10     U28_ISHF U28_U13_MPLL1_dr VSSO    VSS     NH   L=.3600U
+  W=36.0000U
M15     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M20     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M21     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M22     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M23     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M24     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M25     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M26     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M27     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M31     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M32     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M34     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M35     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M36     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M37     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M38     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
D12     VSS     I       DN  1.0000P 4.0000U
R13     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R14     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R39     U29_U74$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R40     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM2   net_m2_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM5   net_m5_VSS_res   VSS   1180.0000 $[RD]
RM6   net_m6_VDD_res   VDD   1180.0000 $[RD]

.ENDS pc3o01hv
.SUBCKT pc3o02 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M8      pgate   net_m8_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M9      pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M10     ngate   net_m10_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M11     U28_U16_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U28_ISHF U28_U16_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M13     U28_U16_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     U28_ISHF U28_U16_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M15     VDDO    U28_U16_MN1_drai U28_U16_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M16     U28_U16_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M17     U28_U16_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M19     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M20     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M21     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M22     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M23     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M24     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M25     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M26     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M27     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M28     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M29     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M30     PAD     U29_U74$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M33     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M34     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M35     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M36     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M37     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M38     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M39     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M40     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M41     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M42     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M43     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M44     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
D18     VSS     I       DN  250.0000F 2.0000U
R31     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R32     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R45     U29_U74$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R46     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM8   net_m8_VDDO_res   VDDO   1180.0000 $[RD]
RM10   net_m10_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3o02
.SUBCKT pc3o03 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M20     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M21     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M22     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M23     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M27     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     U29_ngate3 U30_ngatex U30_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M34     U29_ngate3 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M37     pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M38     ngate   net_m38_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M39     ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M40     pgate   net_m40_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M41     U28_U13_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M42     U28_ISHF U28_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U28_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M44     U28_ISHF U28_U13_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     VDDO    U28_U13_MN1_drai U28_U13_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M46     U28_U13_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M47     U28_U13_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D48     VSS     I       DN  250.0000F 2.0000U
R31     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R32     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R35     U29_U76_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R36     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3o03
.SUBCKT pc3o04 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M20     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M21     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M22     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M23     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M27     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     U29_ngate3 U30_ngatex U30_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M34     U29_ngate3 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M37     pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M38     ngate   net_m38_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M39     ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M40     pgate   net_m40_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M41     U28_U13_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M42     U28_ISHF U28_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U28_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M44     U28_ISHF U28_U13_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     VDDO    U28_U13_MN1_drai U28_U13_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M46     U28_U13_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M47     U28_U13_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D48     VSS     I       DN  250.0000F 2.0000U
R31     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R32     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R35     U29_U76_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R36     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3o04
.SUBCKT pc3o05 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M21     U29_ngate3 U30_ngatex U30_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M22     U29_ngate3 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M23     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M27     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M31     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M32     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M34     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M37     pgate   U27_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M38     ngate   net_m38_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M39     ngate   U27_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M40     pgate   net_m40_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M41     U27_U13_MPLL1_dr U27_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M42     U27_ISHF U27_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U27_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M44     U27_ISHF U27_U13_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     VDDO    U27_U13_MN1_drai U27_U13_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M46     U27_U13_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M47     U27_U13_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D48     VSS     I       DN  250.0000F 2.0000U
R19     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R20     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R35     U29_U76_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R36     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3o05
.SUBCKT pc3t01 PAD I OEN VDD VSS VDDO VSSO
M1      U28_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M2      U28_MPI1_drain U27_padr U28_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M3      U27_padr net_m3_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M4      U27_padr net_m4_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M5      U28_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M6      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M7      U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M8      U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M9      U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M10     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M11     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M13     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M15     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M16     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M18     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M19     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M20     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M21     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M22     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M23     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M24     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M26     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M27     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M28     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M29     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M30     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M31     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M32     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M33     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M34     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M35     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M36     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M37     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M38     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M39     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M40     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M41     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M42     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M43     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M44     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M45     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     U15_pgate net_m54_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M55     U15_pgate net_m55_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M59     VDDO    net_m59_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M60     U27_U71_UN_P_TOP net_m60_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
D17     VSS     I       DN  250.0000F 2.0000U
D25     VSS     OEN     DN  250.0000F 2.0000U
R56     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R57     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R58     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM3   net_m3_VDDO_res   VDDO   1180.0000 $[RD]
RM4   net_m4_VSSO_res   VSSO   1180.0000 $[RD]
RM54   net_m54_VDDO_res   VDDO   1180.0000 $[RD]
RM55   net_m55_VSSO_res   VSSO   1180.0000 $[RD]
RM59   net_m59_VDDO_res   VDDO   1180.0000 $[RD]
RM60   net_m60_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t01
.SUBCKT pc3t01d PAD I OEN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U27_padr net_m56_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M57     U28_U22_source net_m57_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M58     U29_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M59     U29_MPI1_drain U27_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M60     U27_padr net_m60_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M61     U27_padr net_m61_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M62     U29_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM56   net_m56_VDDO_res   VDDO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM60   net_m60_VDDO_res   VDDO   1180.0000 $[RD]
RM61   net_m61_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t01d
.SUBCKT pc3t01u PAD I OEN VDD VSS VDDO VSSO
M1      U27_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      U29_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U29_MPI1_drain U27_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M4      U27_padr net_m4_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M5      U27_padr net_m5_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M6      U29_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M7      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R35     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VSSO_res   VSSO   1180.0000 $[RD]
RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t01u
.SUBCKT pc3t02 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U28_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U28_MPI1_drain U27_padr U28_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     U27_padr net_m65_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M66     U28_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM65   net_m65_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t02
.SUBCKT pc3t02d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U29_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U29_MPI1_drain U27_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     U27_padr net_m65_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M66     U29_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M67     U27_padr net_m67_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M68     U28_U22_source net_m68_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM65   net_m65_VSSO_res   VSSO   1180.0000 $[RD]
RM67   net_m67_VDDO_res   VDDO   1180.0000 $[RD]
RM68   net_m68_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3t02d
.SUBCKT pc3t02u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M16     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M17     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M18     PAD     U27_U69$7_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M19     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M36     VDDO    net_m36_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M37     U27_U71_UN_P_TOP net_m37_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M38     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M39     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M40     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M41     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M44     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M46     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M47     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M48     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M50     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M51     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M52     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M53     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M54     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M55     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M56     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M58     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M59     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M60     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M61     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M62     U30_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_MPI1_drain U27_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M64     U27_padr net_m64_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M65     U27_padr net_m65_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M66     U30_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M67     U27_padr net_m67_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D49     VSS     I       DN  250.0000F 2.0000U
D57     VSS     OEN     DN  250.0000F 2.0000U
R33     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R35     U27_U69$7_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM36   net_m36_VDDO_res   VDDO   1180.0000 $[RD]
RM37   net_m37_VSSO_res   VSSO   1180.0000 $[RD]
RM64   net_m64_VDDO_res   VDDO   1180.0000 $[RD]
RM65   net_m65_VSSO_res   VSSO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t02u
.SUBCKT pc3t03 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t03
.SUBCKT pc3t03d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VDDO_res    U29_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U29_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3t03d
.SUBCKT pc3t03u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M8      U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M9      U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M10     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M11     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M13     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M15     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M16     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M17     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M19     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M20     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M21     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M22     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M23     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M24     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M25     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M27     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M28     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M29     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M30     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M31     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M32     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M33     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M34     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M35     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M36     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M37     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M38     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M39     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M40     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M41     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M42     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M43     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M44     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M45     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     U15_pgate net_m55_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M56     U15_pgate net_m56_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M59     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M60     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     VDDO    net_m62_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M63     U28_U71_UN_P_TOP net_m63_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D18     VSS     I       DN  250.0000F 2.0000U
D26     VSS     OEN     DN  250.0000F 2.0000U
R57     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R58     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R61     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM55   net_m55_VDDO_res   VDDO   1180.0000 $[RD]
RM56   net_m56_VSSO_res   VSSO   1180.0000 $[RD]
RM62   net_m62_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t03u
.SUBCKT pc3t04 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U29_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U29_MPI1_drain U28_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U29_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t04
.SUBCKT pc3t04d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U31_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U31_MPI1_drain U28_padr U31_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U31_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VDDO_res    U30_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U30_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3t04d
.SUBCKT pc3t04u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U15_pgate net_m19_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U15_pgate net_m20_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t04u
.SUBCKT pc3t05 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U31_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U31_MPI1_drain U29_padr U31_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U31_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t05
.SUBCKT pc3t05d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U32_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U32_MPI1_drain U29_padr U32_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U32_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VDDO_res    U31_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U31_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pc3t05d
.SUBCKT pc3t05u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U32_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U32_MPI1_drain U29_padr U32_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U32_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pc3t05u
.SUBCKT pc3x11 Z XIN EN XOUT VDD VSS VDDO VSSO
M1      U8_OUT  U8_IN   VDD     VDD     P   L=.3600U  W=23.5000U
M2      U8_OUT  U8_IN   VSS     VSS     N   L=.3600U  W=10.0000U
M3      U8_IN   EN      VDD     VDD     P   L=.3600U  W=23.5000U
M4      U8_IN   EN      VSS     VSS     N   L=.3600U  W=10.0000U
M5      VDD     U8_OUT  U23_MP4$1_source VDD     PH   L=.4000U    W=52.0000U
M6      VDD     U8_OUT  U23_MP4$0_source VDD     PH   L=.4000U    W=52.0000U
M7      U23_MP4$1_source U22_PADR XOUT    VDD     PH   L=.4000U    W=52.0000U
M8      U23_MP4$0_source U22_PADR XOUT    VDD     PH   L=.4000U    W=52.0000U
M9      VDD     U23_U37_r2 U23_U82$9_source VDD     PH   L=.4000U    W=52.0000U
M10     VDD     U23_U37_r2 U23_U82$8_source VDD     PH   L=.4000U    W=52.0000U
M11     VDD     U23_U37_r2 U23_U82$7_source VDD     PH   L=.4000U    W=52.0000U
M12     VDD     U23_U37_r2 U23_U82$6_source VDD     PH   L=.4000U    W=52.0000U
M13     VDD     U23_U37_r2 U23_U82$5_source VDD     PH   L=.4000U    W=52.0000U
M14     VDD     U23_U37_r2 U23_U82$4_source VDD     PH   L=.4000U    W=52.0000U
M15     VDD     U23_U37_r2 U23_U82$3_source VDD     PH   L=.4000U    W=52.0000U
M16     VDD     U23_U37_r2 U23_U82$2_source VDD     PH   L=.4000U    W=52.0000U
M17     VDD     U23_U37_r2 U23_U82$1_source VDD     PH   L=.4000U    W=52.0000U
M18     VDD     U23_U37_r2 U23_U82$0_source VDD     PH   L=.4000U    W=52.0000U
M19     U23_U82$9_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M20     U23_U82$8_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M21     U23_U82$7_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M22     U23_U82$6_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M23     U23_U82$5_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M24     U23_U82$4_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M25     U23_U82$3_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M26     U23_U82$2_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M27     U23_U82$1_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M28     U23_U82$0_source U23_U37_r2 XOUT    VDD     PH   L=.4000U    W=52.0000U
M31     U23_MN4$1_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M32     U23_MN4$0_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M33     XOUT    U22_PADR U23_MN4$1_drain VSSO     NH   L=.5000U    W=30.0000U
M34     XOUT    U22_PADR U23_MN4$0_drain VSSO     NH   L=.5000U    W=30.0000U
M35     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M36     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M37     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M38     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M39     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M40     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M41     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M42     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M43     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M44     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M58     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M59     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M60     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M61     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M62     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M63     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M64     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M65     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M66     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M67     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M68     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M69     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M75     U22_PADR U22_U82_gate VSS     VSS     N   L=.4000U
+  W=40.0000U
MPCL      U22_PADR  RU1   VDD     VDD     P   L=.500U  W=40.000U
RPUP1     RU1 VDD      1423.3 $[RD] W=2U L=8U
M76     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M77     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M78     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M79     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M80     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M81     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M82     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M83     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M84     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M85     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M86     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M87     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M91     U12_U22_drain U12_U22_gate VSS     VSS     N   L=.3600U
+  W=7.0000U
M92     Z       U12_U22_drain VSS     VSS     N   L=.3600U
+  W=20.0000U
M93     U12_U22_gate U23_padr U12_U19_source VSS     NH   L=.3600U
+  W=4.0000U
M94     U12_U19_source U8_IN   VSS     VSS     NH   L=.3600U
+  W=4.0000U
M95     U12_U22_drain U12_U22_gate VDD     VDD     P   L=.3600U
+  W=18.0000U
M96     U12_U22_gate U8_IN   VDD     VDD     PH   L=.3600U  W=6.0000U
M97     U12_U22_gate U23_padr VDD     VDD     PH   L=.3600U  W=6.0000U
+
M98     Z       U12_U22_drain VDD     VDD     P   L=.3600U
+  W=50.0000U
M99     U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
M100    U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
D88     VSSO    VSS     P3  93.1700P 200.3400U
D89     VSS     VSSO    P3  93.1700P 200.3400U
D90     VSS     EN      DN  2250.0000F 6.0000U
R53     U23_U80_U13_r1 U23_padr   302.0000 $[RE] W=4U L=2.5U
R54     XOUT    U23_U80_U13_r1   302.0000 $[RE] W=4U L=2.5U
R55     U23_U73$1_gate VSS       4.8915K $[RW] W=2.1U L=8.65U
R56     VDD     U23_U72$1_gate   1.1909K $[RW] W=2.1U L=2.1U
R57     VDD     U23_U37_r2   4.8915K $[RW] W=2.1U L=8.65U
R70     U22_U13_r1 U22_PADR   302.0000 $[RE] W=4U L=2.5U
R71     XIN     U22_U13_r1   302.0000 $[RE] W=4U L=2.5U
R72     U22_U82_gate VSS       1.1909K $[RW] W=2.1U L=2.1U
R73     U22_R_PULLDONW_r VSSO      4.8915K $[RW] W=2.1U L=8.65U
R74     VDDO    U22_U79$3_gate   4.8915K $[RW] W=2.1U L=8.65U
R102    U12_U27$1_gate VSS       1.1909K $[RW] W=2.1U L=2.1U

.ENDS pc3x11
.SUBCKT pc3x12 Z XIN EN XOUT VDD VSS VDDO VSSO
M1      U8_OUT  U8_IN   VDD     VDD     P   L=.3600U  W=23.5000U
M2      U8_OUT  U8_IN   VSS     VSS     N   L=.3600U  W=10.0000U
M3      U8_IN   EN      VDD     VDD     P   L=.3600U  W=23.5000U
M4      U8_IN   EN      VSS     VSS     N   L=.3600U  W=10.0000U
M5      VDD     U8_OUT  U23_MP4$4_source VDD     PH   L=.4000U
+  W=52.0000U
M6      VDD     U8_OUT  U23_MP4$3_source VDD     PH   L=.4000U
+  W=52.0000U
M7      VDD     U8_OUT  U23_MP4$2_source VDD     PH   L=.4000U
+  W=52.0000U
M8      VDD     U8_OUT  U23_MP4$1_source VDD     PH   L=.4000U
+  W=52.0000U
M9      VDD     U8_OUT  U23_MP4$0_source VDD     PH   L=.4000U
+  W=52.0000U
M10     U23_MP4$4_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M11     U23_MP4$3_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M12     U23_MP4$2_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M13     U23_MP4$1_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M14     U23_MP4$0_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M15     VDD     U23_U37_r2 U23_U82$6_source VDD     PH   L=.4000U
+  W=52.0000U
M16     VDD     U23_U37_r2 U23_U82$5_source VDD     PH   L=.4000U
+  W=52.0000U
M17     VDD     U23_U37_r2 U23_U82$4_source VDD     PH   L=.4000U
+  W=52.0000U
M18     VDD     U23_U37_r2 U23_U82$3_source VDD     PH   L=.4000U
+  W=52.0000U
M19     VDD     U23_U37_r2 U23_U82$2_source VDD     PH   L=.4000U
+  W=52.0000U
M20     VDD     U23_U37_r2 U23_U82$1_source VDD     PH   L=.4000U
+  W=52.0000U
M21     VDD     U23_U37_r2 U23_U82$0_source VDD     PH   L=.4000U
+  W=52.0000U
M22     U23_U82$6_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M23     U23_U82$5_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M24     U23_U82$4_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M25     U23_U82$3_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M26     U23_U82$2_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M27     U23_U82$1_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M28     U23_U82$0_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M31     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M32     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M33     U23_MN4$3_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M34     U23_MN4$2_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M35     U23_MN4$1_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M36     U23_MN4$0_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M37     XOUT    U22_PADR U23_MN4$3_drain VSSO     NH   L=.5000U    W=30.0000U
M38     XOUT    U22_PADR U23_MN4$2_drain VSSO     NH   L=.5000U    W=30.0000U
M39     XOUT    U22_PADR U23_MN4$1_drain VSSO     NH   L=.5000U    W=30.0000U
M40     XOUT    U22_PADR U23_MN4$0_drain VSSO     NH   L=.5000U    W=30.0000U
M41     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M42     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M43     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M44     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M45     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M46     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M58     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M59     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M60     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M61     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M62     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M63     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M64     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M65     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M66     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M67     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M68     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M69     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M75     U22_PADR U22_U82_gate VSS     VSS     N   L=.4000U
+  W=40.0000U
MPCL      U22_PADR  RU1   VDD     VDD     P   L=.500U  W=40.000U
RPUP1     RU1 VDD      1423.3 $[RD] W=2U L=8U
M76     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M77     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M78     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M79     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M80     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M81     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M82     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M83     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M84     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M85     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M86     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M87     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M90     U12_U22_drain U12_U22_gate VSS     VSS     N   L=.3600U
+  W=7.0000U
M91     Z       U12_U22_drain VSS     VSS     N   L=.3600U
+  W=20.0000U
M92     U12_U22_gate U23_padr U12_U19_source VSS     NH   L=.3600U
+  W=4.0000U
M93     U12_U19_source U8_IN   VSS     VSS     NH   L=.3600U
+  W=4.0000U
M94     U12_U22_drain U12_U22_gate VDD     VDD     P   L=.3600U
+  W=18.0000U
M95     U12_U22_gate U8_IN   VDD     VDD     PH   L=.3600U  W=6.0000U
M96     U12_U22_gate U23_padr VDD     VDD     PH   L=.3600U  W=6.0000U
+
M97     Z       U12_U22_drain VDD     VDD     P   L=.3600U
+  W=50.0000U
M98     U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
M99     U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
D88     VSSO    VSS     P3  93.1700P 200.3400U
D89     VSS     VSSO    P3  93.1700P 200.3400U
D102    VSS     EN      DN  2250.0000F 6.0000U
R53     U23_U80_U13_r1 U23_padr   302.0000 $[RE] W=4U L=2.5U
R54     XOUT    U23_U80_U13_r1   302.0000 $[RE] W=4U L=2.5U
R55     U23_U73$1_gate VSS       4.8915K $[RW] W=2.1U L=8.65U
R56     VDD     U23_U72$1_gate   1.1909K $[RW] W=2.1U L=2.1U
R57     VDD     U23_U37_r2   4.8915K $[RW] W=2.1U L=8.65U
R70     U22_U13_r1 U22_PADR   302.0000 $[RE] W=4U L=2.5U
R71     XIN     U22_U13_r1   302.0000 $[RE] W=4U L=2.5U
R72     U22_U82_gate VSS       1.1909K $[RW] W=2.1U L=2.1U
R73     U22_R_PULLDONW_r VSSO      4.8915K $[RW] W=2.1U L=8.65U
R74     VDDO    U22_U79$3_gate   4.8915K $[RW] W=2.1U L=8.65U
R101    U12_U27$1_gate VSS       1.1909K $[RW] W=2.1U L=2.1U

.ENDS pc3x12
.SUBCKT pc3x13 Z XIN EN XOUT VDD VSS VDDO VSSO
M1      U8_OUT  U8_IN   VDD     VDD     P   L=.3600U  W=23.5000U
M2      U8_OUT  U8_IN   VSS     VSS     N   L=.3600U  W=10.0000U
M3      U8_IN   EN      VDD     VDD     P   L=.3600U  W=23.5000U
M4      U8_IN   EN      VSS     VSS     N   L=.3600U  W=10.0000U
M5      VDD     U8_OUT  U23_MP4$7_source VDD     PH   L=.4000U
+  W=52.0000U
M6      VDD     U8_OUT  U23_MP4$6_source VDD     PH   L=.4000U
+  W=52.0000U
M7      VDD     U8_OUT  U23_MP4$5_source VDD     PH   L=.4000U
+  W=52.0000U
M8      VDD     U8_OUT  U23_MP4$4_source VDD     PH   L=.4000U
+  W=52.0000U
M9      VDD     U8_OUT  U23_MP4$3_source VDD     PH   L=.4000U
+  W=52.0000U
M10     VDD     U8_OUT  U23_MP4$2_source VDD     PH   L=.4000U
+  W=52.0000U
M11     VDD     U8_OUT  U23_MP4$1_source VDD     PH   L=.4000U
+  W=52.0000U
M12     VDD     U8_OUT  U23_MP4$0_source VDD     PH   L=.4000U
+  W=52.0000U
M13     U23_MP4$7_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M14     U23_MP4$6_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M15     U23_MP4$5_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M16     U23_MP4$4_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M17     U23_MP4$3_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M18     U23_MP4$2_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M19     U23_MP4$1_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M20     U23_MP4$0_source U22_PADR XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M21     VDD     U23_U37_r2 U23_U85$3_source VDD     PH   L=.4000U
+  W=52.0000U
M22     VDD     U23_U37_r2 U23_U85$2_source VDD     PH   L=.4000U
+  W=52.0000U
M23     VDD     U23_U37_r2 U23_U85$1_source VDD     PH   L=.4000U
+  W=52.0000U
M24     VDD     U23_U37_r2 U23_U85$0_source VDD     PH   L=.4000U
+  W=52.0000U
M25     U23_U85$3_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M26     U23_U85$2_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M27     U23_U85$1_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M28     U23_U85$0_source U23_U37_r2 XOUT    VDD     PH   L=.4000U
+  W=52.0000U
M31     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M32     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M33     U23_MN4$5_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M34     U23_MN4$4_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M35     U23_MN4$3_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M36     U23_MN4$2_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M37     U23_MN4$1_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M38     U23_MN4$0_drain U8_IN   VSSO     VSSO     NH   L=.5000U    W=30.0000U
M39     XOUT    U22_PADR U23_MN4$5_drain VSSO     NH   L=.5000U    W=30.0000U
M40     XOUT    U22_PADR U23_MN4$4_drain VSSO     NH   L=.5000U    W=30.0000U
M41     XOUT    U22_PADR U23_MN4$3_drain VSSO     NH   L=.5000U    W=30.0000U
M42     XOUT    U22_PADR U23_MN4$2_drain VSSO     NH   L=.5000U    W=30.0000U
M43     XOUT    U22_PADR U23_MN4$1_drain VSSO     NH   L=.5000U    W=30.0000U
M44     XOUT    U22_PADR U23_MN4$0_drain VSSO     NH   L=.5000U    W=30.0000U
M45     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M46     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M47     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M48     XOUT U23_U73$1_gate VSSO     VSSO     NH   L=.4000U    W=30.0000U
M58     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M59     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M60     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M61     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M62     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M63     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M64     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M65     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M66     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M67     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M68     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M69     VDDO    U22_U79$3_gate XIN     VDDO    PH   L=.4000U
+  W=52.0000U
M75     U22_PADR U22_U82_gate VSS     VSS     N   L=.4000U
+  W=40.0000U
MPCL      U22_PADR  RU1   VDD     VDD     P   L=.500U  W=40.000U
RPUP1     RU1 VDD      1423.3 $[RD] W=2U L=8U

M76     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M77     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M78     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M79     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M80     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M81     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M82     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M83     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M84     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M85     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M86     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M87     XIN     U22_R_PULLDONW_r VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M91     U12_U22_drain U12_U22_gate VSS     VSS     N   L=.3600U
+  W=7.0000U
M92     Z       U12_U22_drain VSS     VSS     N   L=.3600U
+  W=20.0000U
M93     U12_U22_gate U23_padr U12_U19_source VSS     NH   L=.3600U
+  W=4.0000U
M94     U12_U19_source U8_IN   VSS     VSS     NH   L=.3600U
+  W=4.0000U
M95     U12_U22_drain U12_U22_gate VDD     VDD     P   L=.3600U
+  W=18.0000U
M96     U12_U22_gate U8_IN   VDD     VDD     PH   L=.3600U  W=6.0000U
M97     U12_U22_gate U23_padr VDD     VDD     PH   L=.3600U  W=6.0000U
+
M98     Z       U12_U22_drain VDD     VDD     P   L=.3600U
+  W=50.0000U
M99     U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
M100    U23_padr     U12_U27$1_gate VSS     VSS     N  L=.4000U
+  W=15.0000U
D88     VSSO    VSS     P3  93.1700P 200.3400U
D89     VSS     VSSO    P3  93.1700P 200.3400U
D90     VSS     EN      DN  2250.0000F 6.0000U
R53     U23_U80_U13_r1 U23_padr   302.0000 $[RE] W=4U L=2.5U
R54     XOUT    U23_U80_U13_r1   302.0000 $[RE] W=4U L=2.5U
R55     U23_U73$1_gate VSS       4.8915K $[RW] W=2.1U L=8.65U
R56     VDD     U23_U72$1_gate   1.1909K $[RW] W=2.1U L=2.1U
R57     VDD     U23_U37_r2   4.8915K $[RW] W=2.1U L=8.65U
R70     U22_U13_r1 U22_PADR   302.0000 $[RE] W=4U L=2.5U
R71     XIN     U22_U13_r1   302.0000 $[RE] W=4U L=2.5U
R72     U22_U82_gate VSS       1.1909K $[RW] W=2.1U L=2.1U
R73     U22_R_PULLDONW_r VSSO      4.8915K $[RW] W=2.1U L=8.65U
R74     VDDO    U22_U79$3_gate   4.8915K $[RW] W=2.1U L=8.65U
R102    U12_U27$1_gate VSS       1.1909K $[RW] W=2.1U L=2.1U

.ENDS pc3x13
.SUBCKT pt3b01 PAD I OEN CIN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M57     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M58     U27_padr net_m58_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M59     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M60     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M61     U27_padr net_m61_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M62     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM58   net_m58_VDDO_res   VDDO   1180.0000 $[RD]
RM61   net_m61_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b01
.SUBCKT pt3b01d PAD I OEN CIN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U27_padr net_m56_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M57     U28_U22_source net_m57_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M58     U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M59     U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M60     U27_padr net_m60_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M61     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M62     U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M63     U27_padr net_m63_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M64     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM56   net_m56_VDDO_res   VDDO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM60   net_m60_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b01d
.SUBCKT pt3b01u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U27_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      U26_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U26_MPI1_drain U27_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M4      U27_padr net_m4_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M5      CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M6      U26_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M7      U27_padr net_m7_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M8      CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M9      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M10     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M11     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M12     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M13     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M14     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M15     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M16     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M17     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M18     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M19     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M21     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M22     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M23     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M24     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M25     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M26     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M27     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M29     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M30     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M31     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M33     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M34     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M35     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M36     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M37     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M38     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M39     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M40     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M41     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M42     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M43     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M44     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M45     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M56     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M57     U15_pgate net_m57_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M58     U15_pgate net_m58_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M62     VDDO    net_m62_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M63     U27_U71_UN_P_TOP net_m63_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
D20     VSS     I       DN  250.0000F 2.0000U
D28     VSS     OEN     DN  250.0000F 2.0000U
R59     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R60     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R61     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM7   net_m7_VSSO_res   VSSO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM58   net_m58_VSSO_res   VSSO   1180.0000 $[RD]
RM62   net_m62_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b01u
.SUBCKT pt3b02 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b02
.SUBCKT pt3b02d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VDDO_res    U29_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M72     U29_U22_source net_m72_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]
RM72   net_m72_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3b02d
.SUBCKT pt3b02u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U28_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U28_padr net_m71_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b02u
.SUBCKT pt3b03 PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b03
.SUBCKT pt3b03d PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U29_padr net_m71_VDDO_res    U31_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M72     U31_U22_source net_m72_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VDDO_res   VDDO   1180.0000 $[RD]
RM72   net_m72_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3b03d
.SUBCKT pt3b03u PAD I OEN CIN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U26_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U26_MPI1_drain U29_padr U26_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     CIN     U26_MPI1_drain VDD     VDD     PH   L=.3600U
+  W=32.0000U
M68     U26_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M70     CIN     U26_MPI1_drain VSS     VSS     NH   L=.3600U
+  W=6.0000U
M71     U29_padr net_m71_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]
RM71   net_m71_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3b03u
.SUBCKT pt3o01 PAD I VDD VSS VDDO VSSO
M3      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M4      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M5      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M14     PAD     U29_U74$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M15     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M16     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M17     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M18     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M19     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M20     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M21     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M22     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M23     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M30     pgate   net_m30_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M31     pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M32     ngate   net_m32_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M33     U28_U16_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M34     U28_ISHF U28_U16_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M35     U28_U16_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M36     U28_ISHF U28_U16_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M37     VDDO    U28_U16_MN1_drai U28_U16_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M38     U28_U16_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M39     U28_U16_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D40     VSS     I       DN  250.0000F 2.0000U
R1      PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R2      U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R27     U29_U74$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R28     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3o01
.SUBCKT pt3o02 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M20     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M21     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M22     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M23     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M27     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     U29_ngate3 U30_ngatex U30_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M34     U29_ngate3 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M37     pgate   U28_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M38     ngate   net_m38_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M39     ngate   U28_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M40     pgate   net_m40_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M41     U28_U13_MPLL1_dr U28_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M42     U28_ISHF U28_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U28_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M44     U28_ISHF U28_U13_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     VDDO    U28_U13_MN1_drai U28_U13_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M46     U28_U13_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M47     U28_U13_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D48     VSS     I       DN  250.0000F 2.0000U
R31     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R32     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R35     U29_U76_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R36     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3o02
.SUBCKT pt3o03 PAD I VDD VSS VDDO VSSO
M1      U30_ngatex ngate   VSSO    VSS     NH   L=.3600U  W=10.0000U
M2      U30_ngatex ngate   VDDO    VDDO    PH   L=.3600U  W=7.0000U
M3      U30_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U30_ngate2 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U30_ngate2 U30_ngatex U30_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U30_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U30_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     ngate   VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U29_U76_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M21     U29_ngate3 U30_ngatex U30_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M22     U29_ngate3 U30_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M23     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M24     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M25     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M26     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M27     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M28     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M29     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M30     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M31     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M32     VDDO    pgate   PAD     VDDO    PH   L=.4000U  W=52.0000U
M33     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M34     VDDO    U29_U37_r2 PAD     VDDO    PH   L=.4000U  W=52.0000U
M37     pgate   U27_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M38     ngate   net_m38_VSSO_res    pgate   VDDO    PH   L=.3600U  W=30.0000U
M39     ngate   U27_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M40     pgate   net_m40_VDDO_res    ngate   VSS     NH   L=.3600U  W=30.0000U
M41     U27_U13_MPLL1_dr U27_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M42     U27_ISHF U27_U13_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M43     U27_U13_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M44     U27_ISHF U27_U13_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M45     VDDO    U27_U13_MN1_drai U27_U13_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M46     U27_U13_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M47     U27_U13_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
D48     VSS     I       DN  250.0000F 2.0000U
R19     PAD     U29_U69_U17_r2 302.0000 $[RE]  W=4U L=2.5U
R20     U29_U69_U17_r2 U29_U69_padr 302.0000 $[RE]  W=4U L=2.5U
R35     U29_U76_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U
R36     VDDO    U29_U37_r2 4.8910K $[RW]  W=2.1U L=8.65U

RM38   net_m38_VSSO_res   VSSO   1180.0000 $[RD]
RM40   net_m40_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3o03
.SUBCKT pt3t01 PAD I OEN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U28_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M57     U28_MPI1_drain U27_padr U28_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M58     U27_padr net_m58_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M59     U27_padr net_m59_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M60     U28_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM58   net_m58_VDDO_res   VDDO   1180.0000 $[RD]
RM59   net_m59_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t01
.SUBCKT pt3t01d PAD I OEN VDD VSS VDDO VSSO
M1      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M2      PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M3      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M4      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M5      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M6      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M7      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M8      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M9      PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M10     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M11     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M12     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M13     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M14     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M15     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M16     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M17     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M18     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M19     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     U15_pgate net_m25_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M26     U15_pgate net_m26_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M30     VDDO    net_m30_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M31     U27_U71_UN_P_TOP net_m31_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M32     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M33     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M34     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M35     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M36     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M37     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M38     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M39     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M40     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M41     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M42     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M44     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M45     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M46     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M48     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M53     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M54     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M55     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M56     U27_padr net_m56_VDDO_res    U28_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M57     U28_U22_source net_m57_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
M58     U29_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M59     U29_MPI1_drain U27_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M60     U27_padr net_m60_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M61     U27_padr net_m61_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M62     U29_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D43     VSS     I       DN  250.0000F 2.0000U
D51     VSS     OEN     DN  250.0000F 2.0000U
R27     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R28     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R29     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM25   net_m25_VDDO_res   VDDO   1180.0000 $[RD]
RM26   net_m26_VSSO_res   VSSO   1180.0000 $[RD]
RM30   net_m30_VDDO_res   VDDO   1180.0000 $[RD]
RM31   net_m31_VSSO_res   VSSO   1180.0000 $[RD]
RM56   net_m56_VDDO_res   VDDO   1180.0000 $[RD]
RM57   net_m57_VDDO_res   VDDO   1180.0000 $[RD]
RM60   net_m60_VDDO_res   VDDO   1180.0000 $[RD]
RM61   net_m61_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t01d
.SUBCKT pt3t01u PAD I OEN VDD VSS VDDO VSSO
M1      U27_padr net_m1_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
M2      U29_MPI2_drain U27_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M3      U29_MPI1_drain U27_padr U29_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M4      U27_padr net_m4_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M5      U27_padr net_m5_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M6      U29_MPI1_drain U27_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M7      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M8      U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M9      U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M10     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M11     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M13     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M15     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M16     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M17     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M19     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M20     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M21     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M22     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M23     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M24     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M25     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M27     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M28     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M29     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M30     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M31     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M32     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M33     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M34     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M35     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M36     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M37     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M38     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M39     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M40     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M41     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M42     PAD     U27_U69$9_gate VSSO    VSSO    NH   L=.5000U
+  W=30.0000U
M43     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M44     VDDO    U27_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M45     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U27_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     U15_pgate net_m55_VDDO_res    U27_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M56     U15_pgate net_m56_VSSO_res    U27_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M60     VDDO    net_m60_VDDO_res    U27_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M61     U27_U71_UN_P_TOP net_m61_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
D18     VSS     I       DN  250.0000F 2.0000U
D26     VSS     OEN     DN  250.0000F 2.0000U
R57     U27_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R58     U27_padr U27_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R59     U27_U69$9_gate VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM1   net_m1_VSSO_res   VSSO   1180.0000 $[RD]
RM4   net_m4_VDDO_res   VDDO   1180.0000 $[RD]
RM5   net_m5_VSSO_res   VSSO   1180.0000 $[RD]
RM55   net_m55_VDDO_res   VDDO   1180.0000 $[RD]
RM56   net_m56_VSSO_res   VSSO   1180.0000 $[RD]
RM60   net_m60_VDDO_res   VDDO   1180.0000 $[RD]
RM61   net_m61_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t01u
.SUBCKT pt3t02 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t02
.SUBCKT pt3t02d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M20     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M21     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M22     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M23     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M24     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M25     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     U15_pgate net_m31_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M32     U15_pgate net_m32_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M35     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M36     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M38     VDDO    net_m38_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U28_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M41     U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M42     U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M43     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M44     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VDDO_res    U29_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U29_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R33     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R34     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM31   net_m31_VDDO_res   VDDO   1180.0000 $[RD]
RM32   net_m32_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3t02d
.SUBCKT pt3t02u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U15_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U15_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      U15_ngate U15_ISHF VSSO    VSS     NH   L=.3600U  W=20.1000U
M8      U15_pgate U15_U12_oenb U15_ngate VSS     NH   L=.3600U
+  W=30.0000U
M9      U15_pgate U15_ISHF VDDO    VDDO    PH   L=.3600U  W=40.1000U
M10     U15_ngate U15_U15_OUTSHIFT U15_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M11     U15_U14_MPLL1_dr U15_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M12     U15_ISHF U15_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M13     U15_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M14     U15_ISHF U15_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M15     VDDO    U15_U14_MN1_drai U15_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M16     U15_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M17     U15_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M19     U15_U15_MPLL1_dr U15_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M20     U15_U15_OUTSHIFT U15_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M21     U15_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M22     U15_U15_OUTSHIFT U15_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M23     VDDO    U15_U15_MN1_drai U15_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M24     U15_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M25     U15_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M27     U15_ngate U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M28     U15_U12_oenb U15_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M29     U15_U12_oenb U15_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M30     U15_pgate U15_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M31     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M32     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M33     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M34     PAD     U28_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M35     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M36     PAD     U15_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M37     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M38     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M39     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M40     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M41     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M42     PAD     U28_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M43     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M44     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M45     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M46     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M47     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M48     VDDO    U28_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M49     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M50     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M51     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M52     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M53     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M54     VDDO    U28_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M55     U15_pgate net_m55_VDDO_res    U28_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M56     U15_pgate net_m56_VSSO_res    U28_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M59     U28_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M60     U28_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     VDDO    net_m62_VDDO_res    U28_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M63     U28_U71_UN_P_TOP net_m63_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U30_MPI2_drain U28_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U30_MPI1_drain U28_padr U30_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U28_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U28_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U30_MPI1_drain U28_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U28_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D18     VSS     I       DN  250.0000F 2.0000U
D26     VSS     OEN     DN  250.0000F 2.0000U
R57     U28_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R58     U28_padr U28_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R61     U28_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM55   net_m55_VDDO_res   VDDO   1180.0000 $[RD]
RM56   net_m56_VSSO_res   VSSO   1180.0000 $[RD]
RM62   net_m62_VDDO_res   VDDO   1180.0000 $[RD]
RM63   net_m63_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t02u
.SUBCKT pt3t03 PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U31_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U31_MPI1_drain U29_padr U31_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U31_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t03
.SUBCKT pt3t03d PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U32_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U32_MPI1_drain U29_padr U32_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U32_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VDDO_res    U31_U22_source VSS     NH   L=5.5000U
+  W=2.0000U
M70     U31_U22_source net_m70_VDDO_res    VSSO    VSS     NH   L=5.5000U
+  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VDDO_res   VDDO   1180.0000 $[RD]
RM70   net_m70_VDDO_res   VDDO   1180.0000 $[RD]

.ENDS pt3t03d
.SUBCKT pt3t03u PAD I OEN VDD VSS VDDO VSSO
M1      U17_ngatex U30_ngate VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M2      U17_ngatex U30_ngate VDDO    VDDO    PH   L=.3600U  W=7.0000U
+
M3      U17_ngate2 I       VSSO    VSS     NH   L=.3600U  W=15.0000U
M4      U17_ngate2 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=1.0000U
M5      U17_ngate2 U17_ngatex U17_U15_U8_sourc VDDO    PH   L=.3600U
+  W=15.0000U
M6      U17_U15_U8_sourc I       VDDO    VDDO    PH   L=.3600U
+  W=15.0000U
M7      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M8      PAD     U29_ngate3 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M9      PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M10     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M11     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M12     PAD     U17_ngate2 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M13     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M14     PAD     U29_U42_r1 VSSO    VSSO    NH   L=.5000U  W=30.0000U
M15     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M16     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M17     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M18     PAD     U30_ngate VSSO    VSSO    NH   L=.5000U  W=30.0000U
M19     U30_pgate net_m19_VDDO_res    U29_U72_pgate VSS     NH   L=.3600U
+  W=50.0000U
M20     U30_pgate net_m20_VSSO_res    U29_U72_pgate VDDO    PH   L=.3600U
+  W=50.0000U
M23     U29_ngate3 U17_ngatex U17_ngate2 VDDO    PH   L=.3600U
+  W=5.0000U
M24     U29_ngate3 U17_ngatex VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M25     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M26     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M27     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M28     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M29     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M30     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M31     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M32     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M33     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M34     VDDO    U29_U72_pgate PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M35     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M36     VDDO    U29_U71_UN_P_TOP PAD     VDDO    PH   L=.4000U
+  W=52.0000U
M38     VDDO    net_m38_VDDO_res    U29_U71_UN_P_TOP VSS     NH   L=.3600U
+  W=10.0000U
M39     U29_U71_UN_P_TOP net_m39_VSSO_res    VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M40     U30_pgate U30_ISHF VDDO    VDDO    PH   L=.3600U  W=60.0000U
M41     U30_ngate U30_U15_OUTSHIFT U30_pgate VDDO    PH   L=.3600U
+  W=30.0000U
M42     U30_ngate U30_ISHF VSSO    VSS     NH   L=.3600U  W=30.0000U
M43     U30_pgate U30_U12_oenb U30_ngate VSS     NH   L=.3600U
+  W=30.0000U
M44     U30_U14_MPLL1_dr U30_ISHF VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M45     U30_ISHF U30_U14_MPLL1_dr VDDO    VDDO    PH   L=.3600U
+  W=7.2000U
M46     U30_U14_MPLL1_dr I       VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M47     U30_ISHF U30_U14_MN1_drai VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M48     VDDO    U30_U14_MN1_drai U30_U14_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M49     U30_U14_MN1_drai I       VSS     VSS     N   L=.1800U
+  W=5.0000U
M50     U30_U14_MN1_drai I       VDD     VDD     P   L=.1800U
+  W=10.0000U
M52     U30_U15_MPLL1_dr U30_U15_OUTSHIFT VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M53     U30_U15_OUTSHIFT U30_U15_MPLL1_dr VDDO    VDDO    PH
+  L=.3600U  W=7.2000U
M54     U30_U15_MPLL1_dr OEN     VSSO    VSS     NH   L=.3600U
+  W=20.0000U
M55     U30_U15_OUTSHIFT U30_U15_MN1_drai VSSO    VSS     NH
+  L=.3600U  W=20.0000U
M56     VDDO    U30_U15_MN1_drai U30_U15_MPLL1_dr VSS     NH
+  L=.3600U  W=5.0000U
M57     U30_U15_MN1_drai OEN     VSS     VSS     N   L=.1800U
+  W=5.0000U
M58     U30_U15_MN1_drai OEN     VDD     VDD     P   L=.1800U
+  W=10.0000U
M60     U30_ngate U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M61     U30_U12_oenb U30_U15_OUTSHIFT VSSO    VSS     NH   L=.3600U
+  W=10.0000U
M62     U30_U12_oenb U30_U15_OUTSHIFT VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M63     U30_pgate U30_U12_oenb VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M64     U32_MPI2_drain U29_padr VDDO    VDDO    PH   L=.3600U
+  W=20.0000U
M65     U32_MPI1_drain U29_padr U32_MPI2_drain VDDO    PH   L=.3600U
+  W=20.0000U
M66     U29_padr net_m66_VDDO_res    VDDO    VDDO    PH   L=.3600U  W=20.0000U
M67     U29_padr net_m67_VSSO_res    VSSO    VSS     NH   L=.3600U  W=20.0000U
M68     U32_MPI1_drain U29_padr VSSO    VSS     NH   L=.3600U
+  W=6.0000U
M69     U29_padr net_m69_VSSO_res    VDDO    VDDO    PH   L=2.0000U  W=2.0000U
D51     VSS     I       DN  250.0000F 2.0000U
D59     VSS     OEN     DN  250.0000F 2.0000U
R21     U29_U72_U13_r1 PAD     302.0000 $[RE]  W=4U L=2.5U
R22     U29_padr U29_U72_U13_r1 302.0000 $[RE]  W=4U L=2.5U
R37     U29_U42_r1 VSSO    4.8910K $[RW]  W=2.1U L=8.65U

RM19   net_m19_VDDO_res   VDDO   1180.0000 $[RD]
RM20   net_m20_VSSO_res   VSSO   1180.0000 $[RD]
RM38   net_m38_VDDO_res   VDDO   1180.0000 $[RD]
RM39   net_m39_VSSO_res   VSSO   1180.0000 $[RD]
RM66   net_m66_VDDO_res   VDDO   1180.0000 $[RD]
RM67   net_m67_VSSO_res   VSSO   1180.0000 $[RD]
RM69   net_m69_VSSO_res   VSSO   1180.0000 $[RD]

.ENDS pt3t03u
.SUBCKT pv0a VSSO VDD VSS VDDO
C4_5    VDDO    U31_U29_c2 L= 15.13U W=15.13U $[CH]
M4      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M5      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M6      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M7      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M8      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M9      VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M10     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M11     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M12     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M13     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M14     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M15     VDDO    U31_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M16     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M17     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M18     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M19     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M20     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M21     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M22     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M23     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M24     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M25     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M26     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M27     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
D30     VSS     VSSO    P3  119.7900P 257.5800U
D31     VSSO    VSS     P3  119.7900P 257.5800U
R2      U31_U29_c2 U31_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R3      U31_U18_r2 VSSO    8.2500K $[RW]  W=2.1U L=14.6U
R28     VDDO    U19_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R29     U19_U18_r2 U19_U22$11_gate 8.2500K $[RW]  W=2.1U L=14.6U

.ENDS pv0a
.SUBCKT pv0c VSSC VDD VSS VDDO VSSO
C8_1    VDD U33_U29_c2     L= 15.13U W=15.13U $[CH]
M3      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M4      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M5      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M6      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M7      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M8      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M9      VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M10     VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M11     VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M12     VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M13     VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M14     VSSC    U34_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M18     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M19     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M20     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M21     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M22     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M23     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M24     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M25     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M26     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M27     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M28     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
M29     VDD     U33_U29_c2 VSSC    VSSC   N   L=.2500U  W=30.0000U
D30     VSSC    VSS     P3  119.7900P 257.5800U
D31     VSS     VSSC    P3  119.7900P 257.5800U
R1      VDD     U34_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R2      U34_U18_r2 U34_U31_r2 8.2500K $[RW]  W=2.1U L=14.6U
R16     U33_U29_c2 U33_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R17     U33_U18_r2 VSSC    8.2500K $[RW]  W=2.1U L=14.6U

.ENDS pv0c
.SUBCKT pv0f VSS VDD VDDO VSSO
C3_5    VDDO    U37_U29_c2 L= 15.13U W=15.13U $[CH]
M4      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M5      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M6      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M7      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M8      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M9      VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M10     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M11     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M12     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M13     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M14     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M15     VDDO    U37_U29_c2 VSS     VSS     NH   L=.4000U  W=30.0000U
M16     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M17     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M18     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M19     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M20     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M21     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M22     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M23     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M24     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M25     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M26     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M27     VSS     U34_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
D30     VSS     VSS     P3  119.7900P 257.5800U
D31     VSS     VSS     P3  119.7900P 257.5800U
R2      U37_U29_c2 U37_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R3      U37_U18_r2 VSS     8.2500K $[RW]  W=2.1U L=14.6U
R28     VDDO    U34_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R29     U34_U18_r2 U34_U22$11_gate 8.2500K $[RW]  W=2.1U L=14.6U

.ENDS pv0f
.SUBCKT pv0i VSS VDD VDDO VSSO
C8_1    VDD U31_U18_r1     L= 15.13U W=15.13U $[CH]
M3      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M4      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M5      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M6      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M7      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M8      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M9      VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M10     VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M11     VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M12     VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M13     VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M14     VSS     U33_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M18     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M19     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M20     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M21     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M22     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M23     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M24     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M25     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M26     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M27     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M28     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
M29     VDD     U31_U18_r1 VSS     VSS    N   L=.2500U  W=30.0000U
D30     VSSO    VSS     P3  119.7900P 257.5800U
D31     VSS     VSSO    P3  119.7900P 257.5800U
R1      U33_U31_r1 U33_U31_r2   8.2500K $[RW] W=2.1U L=14.6U
R2      VDD     U33_U31_r1   8.2500K $[RW] W=2.1U L=14.6U
R15     U31_U31_r1 VSS       8.2500K $[RW] W=2.1U L=14.6U
R16     U31_U18_r1 U31_U31_r1   8.2500K $[RW] W=2.1U L=14.6U

.ENDS pv0i
.SUBCKT pvce VDD VSS VDDO VSSO

.ENDS pvce
.SUBCKT pvcf VDD VSS VDDO VSSO

.ENDS pvcf
.SUBCKT pvda VDDO VDD VSS VSSO
C3_5    VDDO    U30_U29_c2 L= 15.13U W=15.13U $[CH]
M4      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M5      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M6      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M7      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M8      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M9      VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M10     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M11     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M12     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M13     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M14     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M15     VDDO    U30_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M16     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M17     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M18     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M19     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M20     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M21     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M22     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M23     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M24     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M25     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M26     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
M27     VSSO    U19_U22$11_gate VDDO    VDDO    PH   L=.4000U
+  W=40.0000U
D30     VSS     VSSO    P3  119.7900P 257.5800U
D31     VSSO    VSS     P3  119.7900P 257.5800U
R2      U30_U29_c2 U30_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R3      U30_U18_r2 VSSO    8.2500K $[RW]  W=2.1U L=14.6U
R28     VDDO    U19_U18_r2 8.2500K $[RW]  W=2.1U L=14.6U
R29     U19_U18_r2 U19_U22$11_gate 8.2500K $[RW]  W=2.1U L=14.6U

.ENDS pvda
.SUBCKT pvdc VDDC VDD VSS VDDO VSSO
C3_6    VDDC    U36_U29_c2 L= 15.13U W=15.13U $[CH]
M4      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M5      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M6      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M7      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M8      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M9      VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M10     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M11     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M12     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M13     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M14     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M15     VDDC    U36_U29_c2 VSSO    VSSO    NH   L=.4000U  W=30.0000U
M16     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M17     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M18     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M19     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M20     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M21     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M22     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M23     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M24     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M25     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M26     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
M27     VSS     U35_U22$11_gate VDDC    VDDC    PH   L=.4000U
+  W=40.0000U
D30     VSSO    VSS     P3  119.7900P 257.5800U
D31     VSS     VSSO    P3  119.7900P 257.5800U
R2      U36_U29_c2 U36_U18_r2   8.2500K $[RW] W=2.1U L=14.6U
R3      U36_U18_r2 VSS       8.2500K $[RW] W=2.1U L=14.6U
R28     VDDC    U35_U18_r2   8.2500K $[RW] W=2.1U L=14.6U
R29     U35_U18_r2 U35_U22$11_gate   8.2500K $[RW] W=2.1U L=14.6U

.ENDS pvdc
.SUBCKT pvdi VDD VSS VDDO VSSO
C8_1    VDD U31_U18_r1     L= 15.13U W=15.13U $[CH]
M3      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M4      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M5      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M6      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M7      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M8      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M9      VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M10     VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M11     VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M12     VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M13     VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M14     VSS     U32_U31_r2 VDD     VDD    P   L=.2500U  W=40.0000U
M18     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M19     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M20     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M21     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M22     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M23     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M24     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M25     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M26     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M27     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M28     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
M29     VDD     U31_U18_r1 VSSO    VSSO   N   L=.2500U  W=30.0000U
D30     VSSO    VSS     P3  119.7900P 257.5800U
D31     VSS     VSSO    P3  119.7900P 257.5800U
R1      U32_U31_r1 U32_U31_r2   8.2500K $[RW] W=2.1U L=14.6U
R2      VDD     U32_U31_r1   8.2500K $[RW] W=2.1U L=14.6U
R15     U31_U31_r1 VSS       8.2500K $[RW]  W=2.1U L=14.6U
R16     U31_U18_r1 U31_U31_r1   8.2500K $[RW] W=2.1U L=14.6U

.ENDS pvdi
